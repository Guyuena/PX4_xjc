## px4_simple_cleaner/Kconfig
```kconfig
menuconfig EXAMPLES_PX4_SIMPLE_CLEANER
	bool "px4_simple_cleaner"
	default n
	---help---
		Enable support for px4_simple_cleaner
```
